# Keil uVision project MAIN.uvprojx, settings and files
target PRO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.7
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MAIN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AT32F437VGT7,USE_STDPERIPH_DRIVER
  c include: .\AT_SDK\drivers\inc;.\AT_SDK\cmsis\cm4\core_support;.\AT_SDK\cmsis\cm4\device_support;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\USER;.\DEBUG;.\LWIP\src\include;.\LWIP\src\include\ipv4;.\LWIP\src\include\lwip;.\LWIP\src\include\netif;.\LWIP\port;.\LWIP\port\arch;.\AT_ETH;.\usb_drivers\inc;.\usbd_class\composite_cdc_msc;.\FATFS;.\SPI-FLASH;.\FreeModbus\BARE\port;.\FreeModbus\modbus\rtu;.\FreeModbus\modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\OUTFILES\MAIN.sct
  group START
    ./AT_SDK/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group CMSIS
    ./AT_SDK/cmsis/cm4/device_support/: system_at32f435_437.c
  group LIB
    ./AT_SDK/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group FreeRTOS/Src
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/memmang/: heap_4.c
  group LWIP/API
    ./LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ./LWIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP/IPV4
    ./LWIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    ./LWIP/src/netif/: etharp.c slipif.c
  group LWIP/PORT
    ./LWIP/port/: lwipopts.h ethernetif.c ethernetif.h sys_arch.c
    ./LWIP/port/arch/: sys_arch.h perf.h epstruct.h cc.h bpstruct.h
  group LWIP/ETH
    ./AT_ETH/: at32_emac_phy.c at32_emac_phy.h netconf.c netconf.h
  group USB/CORE
    ./usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group USB/CLASS
    ./usbd_class/composite_cdc_msc/: cdc_msc_class.c cdc_msc_desc.c msc_bot_scsi.c
  group SPI_FLASH
    ./SPI-FLASH/: spi_tranrecv.c spi_tranrecv.h w25x80.c w25x80.h
  group FATFS
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group MODBUS/PORT
    ./FreeModbus/BARE/port/: portevent.c portserial.c porttimer.c
    ./FreeModbus/: mb_callback.c
  group MODBUS/SRC
    ./FreeModbus/modbus/: mb.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group DEBUG
    ./DEBUG/: debug_usart.c debug_usart.h
  group USER
    ./USER/: main.c at32f435_437_clock.c at32f435_437_int.c usb_conf.h msc_diskio.c msc_diskio.h
